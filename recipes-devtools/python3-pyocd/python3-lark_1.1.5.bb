# python3-lark
SUMMARY = "Python package for a modern parsing library"
HOMEPAGE ="https://pypi.org/project/lark"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fcfbf1e2ecc0f37acbb5871aa0267500"

PYPI_PACKAGE = "lark"
SRC_URI[sha256sum] = "4b534eae1f9af5b4ea000bea95776350befe1981658eea3820a01c37e504bb4d"

inherit pypi setuptools3
